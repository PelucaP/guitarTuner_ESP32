/*
 * Minimal DRV8825 (STEP/DIR) stepper driver for ESP-IDF.
 *
 * STEP pulses are generated by RMT. The ramp tables come from Espressif's
 * stepper motor curve encoder (main/stepper_motor_encoder.c, copied from
 * esp-idf/examples/peripherals/rmt/stepper_motor; the unused uniform-speed
 * encoder was removed).
 *
 * The constant-speed phase uses a local encoder instead of the example's
 * uniform encoder: rmt_transmit() rejects loop_count > 1 on the original ESP32
 * because that chip has no RMT TX loop-count hardware (see
 * components/soc/esp32/include/soc/soc_caps.h and rmt_tx.c:525), so the
 * upstream example's loop_count trick returns ESP_ERR_NOT_SUPPORTED here.
 */
#include <assert.h>
#include <inttypes.h>
#include <string.h>

#include "esp_check.h"
#include "esp_log.h"
#include "esp_rom_sys.h"

#include "drv8825.h"
#include "stepper_motor_encoder.h"

static const char *TAG = "drv8825";

#define RMT_RESOLUTION_HZ   1000000   /* 1 tick = 1 us */
#define RMT_MEM_SYMBOLS     64        /* = SOC_RMT_MEM_WORDS_PER_CHANNEL on ESP32 */
#define RMT_QUEUE_DEPTH     4         /* accel + cruise + decel */
#define RMT_MAX_TICKS       32767     /* rmt_symbol_word_t duration is a 15-bit field */
#define MAX_SPEED_HZ        100000
#define RAMP_START_DIV      10        /* ramp starts at speed_hz / 10 */
/* Slowest ramp step (speed_hz / RAMP_START_DIV) must fit in RMT_MAX_TICKS. */
#define MIN_SPEED_HZ        (RAMP_START_DIV * (RMT_RESOLUTION_HZ / RMT_MAX_TICKS / 2 + 1))

/* ------------------------------------------------------------------------- */
/* Encoder that repeats one STEP pulse N times (payload = uint32_t count).   */
/* ------------------------------------------------------------------------- */

typedef struct {
    rmt_encoder_t base;
    rmt_encoder_handle_t copy_encoder;
    rmt_symbol_word_t sym;
    uint32_t remain;
    bool armed;
} repeat_step_encoder_t;

static size_t repeat_step_encode(rmt_encoder_t *encoder, rmt_channel_handle_t channel,
                                 const void *primary_data, size_t data_size, rmt_encode_state_t *ret_state)
{
    repeat_step_encoder_t *enc = __containerof(encoder, repeat_step_encoder_t, base);

    if (!enc->armed) {
        if (data_size != sizeof(uint32_t)) {
            *ret_state = RMT_ENCODING_RESET;
            return 0;
        }
        enc->remain = *(const uint32_t *)primary_data;
        enc->armed = true;
    }

    size_t encoded = 0;
    bool mem_full = false;
    while (enc->remain) {
        rmt_encode_state_t state = RMT_ENCODING_RESET;
        size_t n = enc->copy_encoder->encode(enc->copy_encoder, channel, &enc->sym, sizeof(enc->sym), &state);
        if (n == 0) {
            break; /* RMT memory full */
        }
        encoded += n;
        enc->remain--;
        if (state & RMT_ENCODING_MEM_FULL) {
            mem_full = true;
            break;
        }
    }

    if (enc->remain == 0) {
        enc->armed = false;
        /* Keep MEM_FULL: if the last step landed exactly on a memory block
         * boundary, the driver must defer the EOF word to the next threshold
         * interrupt instead of overwriting an untransmitted step with it. */
        *ret_state = RMT_ENCODING_COMPLETE | (mem_full ? RMT_ENCODING_MEM_FULL : 0);
    } else {
        *ret_state = RMT_ENCODING_MEM_FULL;
    }
    return encoded;
}

static esp_err_t repeat_step_reset(rmt_encoder_t *encoder)
{
    repeat_step_encoder_t *enc = __containerof(encoder, repeat_step_encoder_t, base);
    enc->remain = 0;
    enc->armed = false;
    return rmt_encoder_reset(enc->copy_encoder);
}

static esp_err_t repeat_step_del(rmt_encoder_t *encoder)
{
    repeat_step_encoder_t *enc = __containerof(encoder, repeat_step_encoder_t, base);
    rmt_del_encoder(enc->copy_encoder);
    free(enc);
    return ESP_OK;
}

static esp_err_t repeat_step_new(uint32_t half_period_ticks, rmt_encoder_handle_t *ret_encoder)
{
    ESP_RETURN_ON_FALSE(half_period_ticks > 0 && ret_encoder, ESP_ERR_INVALID_ARG, TAG, "invalid argument");

    repeat_step_encoder_t *enc = rmt_alloc_encoder_mem(sizeof(*enc));
    ESP_RETURN_ON_FALSE(enc, ESP_ERR_NO_MEM, TAG, "no mem for encoder");

    rmt_copy_encoder_config_t copy_config = {};
    esp_err_t err = rmt_new_copy_encoder(&copy_config, &enc->copy_encoder);
    if (err != ESP_OK) {
        free(enc);
        return err;
    }

    /* STEP idles low, one high pulse per microstep (50% duty). */
    enc->sym.level0 = 0;
    enc->sym.duration0 = half_period_ticks;
    enc->sym.level1 = 1;
    enc->sym.duration1 = half_period_ticks;

    enc->base.encode = repeat_step_encode;
    enc->base.reset = repeat_step_reset;
    enc->base.del = repeat_step_del;
    *ret_encoder = &enc->base;
    return ESP_OK;
}

/* ------------------------------------------------------------------------- */
/* Driver                                                                    */
/* ------------------------------------------------------------------------- */

static bool pin_configured(gpio_num_t gpio)
{
    return gpio >= 0;
}

static void apply_microstep(drv8825_t *dev, drv8825_microstep_t microstep)
{
    int m0, m1, m2;
    switch (microstep) {
    case DRV8825_MICROSTEP_FULL: m0 = 0; m1 = 0; m2 = 0; break;
    case DRV8825_MICROSTEP_HALF: m0 = 1; m1 = 0; m2 = 0; break;
    case DRV8825_MICROSTEP_1_4:  m0 = 0; m1 = 1; m2 = 0; break;
    case DRV8825_MICROSTEP_1_8:  m0 = 1; m1 = 1; m2 = 0; break;
    case DRV8825_MICROSTEP_1_16: m0 = 0; m1 = 0; m2 = 1; break;
    case DRV8825_MICROSTEP_1_32: m0 = 1; m1 = 0; m2 = 1; break;
    default:                     m0 = 0; m1 = 0; m2 = 0; break;
    }
    if (dev->m0_gpio >= 0) {
        gpio_set_level(dev->m0_gpio, m0);
    }
    if (dev->m1_gpio >= 0) {
        gpio_set_level(dev->m1_gpio, m1);
    }
    if (dev->m2_gpio >= 0) {
        gpio_set_level(dev->m2_gpio, m2);
    }
}

esp_err_t drv8825_init(drv8825_t *dev, const drv8825_config_t *cfg)
{
    ESP_RETURN_ON_FALSE(dev && cfg, ESP_ERR_INVALID_ARG, TAG, "invalid argument");
    ESP_RETURN_ON_FALSE(GPIO_IS_VALID_OUTPUT_GPIO(cfg->step_gpio) && GPIO_IS_VALID_OUTPUT_GPIO(cfg->dir_gpio),
                        ESP_ERR_INVALID_ARG, TAG, "invalid STEP/DIR gpio");
    ESP_RETURN_ON_FALSE(cfg->speed_hz >= MIN_SPEED_HZ && cfg->speed_hz <= MAX_SPEED_HZ,
                        ESP_ERR_INVALID_ARG, TAG, "speed_hz must be in [%d, %d]", MIN_SPEED_HZ, MAX_SPEED_HZ);

    memset(dev, 0, sizeof(*dev));
    dev->dir_gpio = cfg->dir_gpio;
    dev->dir_cw_level = cfg->dir_cw_level;
    dev->speed_hz = cfg->speed_hz;

    uint64_t all_pins = BIT64(cfg->step_gpio) | BIT64(cfg->dir_gpio);
    uint64_t output_pins = BIT64(cfg->dir_gpio);
    const gpio_num_t optional_pins[] = {cfg->en_gpio, cfg->m0_gpio, cfg->m1_gpio, cfg->m2_gpio};
    for (size_t i = 0; i < sizeof(optional_pins) / sizeof(optional_pins[0]); i++) {
        if (!pin_configured(optional_pins[i])) {
            continue;
        }
        ESP_RETURN_ON_FALSE(GPIO_IS_VALID_OUTPUT_GPIO(optional_pins[i]), ESP_ERR_INVALID_ARG, TAG,
                            "pin %d is not a valid output", optional_pins[i]);
        ESP_RETURN_ON_FALSE(!(all_pins & BIT64(optional_pins[i])), ESP_ERR_INVALID_ARG, TAG,
                            "pin %d used twice", optional_pins[i]);
        all_pins |= BIT64(optional_pins[i]);
        output_pins |= BIT64(optional_pins[i]);
    }
    dev->en_gpio = pin_configured(cfg->en_gpio) ? cfg->en_gpio : GPIO_NUM_NC;
    dev->m0_gpio = pin_configured(cfg->m0_gpio) ? cfg->m0_gpio : GPIO_NUM_NC;
    dev->m1_gpio = pin_configured(cfg->m1_gpio) ? cfg->m1_gpio : GPIO_NUM_NC;
    dev->m2_gpio = pin_configured(cfg->m2_gpio) ? cfg->m2_gpio : GPIO_NUM_NC;

    gpio_config_t io_config = {
        .mode = GPIO_MODE_OUTPUT,
        .intr_type = GPIO_INTR_DISABLE,
        .pin_bit_mask = output_pins,
    };
    ESP_RETURN_ON_ERROR(gpio_config(&io_config), TAG, "gpio_config failed");
    gpio_set_level(dev->dir_gpio, dev->dir_cw_level);
    apply_microstep(dev, cfg->microstep);

    esp_err_t ret = ESP_OK;
    rmt_tx_channel_config_t chan_config = {
        .clk_src = RMT_CLK_SRC_DEFAULT,
        .gpio_num = cfg->step_gpio,
        .mem_block_symbols = RMT_MEM_SYMBOLS,
        .resolution_hz = RMT_RESOLUTION_HZ,
        .trans_queue_depth = RMT_QUEUE_DEPTH,
    };
    ESP_GOTO_ON_ERROR(rmt_new_tx_channel(&chan_config, &dev->chan), err, TAG, "create RMT channel failed");

    uint32_t cruise_half_period = RMT_RESOLUTION_HZ / cfg->speed_hz / 2;
    ESP_GOTO_ON_ERROR(repeat_step_new(cruise_half_period, &dev->cruise_enc), err, TAG, "create cruise encoder failed");

    /* Ramp length is limited by the encoder's requirement that
     * |end_freq_hz - start_freq_hz| >= sample_points - 1. */
    uint32_t start_hz = cfg->speed_hz / RAMP_START_DIV;
    uint32_t delta_hz = cfg->speed_hz - start_hz;
    uint32_t points = cfg->accel_steps;
    if (points > delta_hz + 1) {
        points = delta_hz + 1;
        ESP_LOGW(TAG, "accel_steps clamped to %" PRIu32 " (max %" PRIu32 " Hz of ramp delta)",
                 points, delta_hz);
    }
    if (points < 2) {
        points = 0;
        ESP_LOGW(TAG, "accel_steps too small, moves will run at constant speed");
    } else {
        stepper_motor_curve_encoder_config_t accel_config = {
            .resolution = RMT_RESOLUTION_HZ,
            .sample_points = points,
            .start_freq_hz = start_hz,
            .end_freq_hz = cfg->speed_hz,
        };
        ESP_GOTO_ON_ERROR(rmt_new_stepper_motor_curve_encoder(&accel_config, &dev->accel_enc), err, TAG,
                          "create accel encoder failed");

        stepper_motor_curve_encoder_config_t decel_config = {
            .resolution = RMT_RESOLUTION_HZ,
            .sample_points = points,
            .start_freq_hz = cfg->speed_hz,
            .end_freq_hz = start_hz,
        };
        ESP_GOTO_ON_ERROR(rmt_new_stepper_motor_curve_encoder(&decel_config, &dev->decel_enc), err, TAG,
                          "create decel encoder failed");
    }
    dev->accel_steps = points;

    ESP_GOTO_ON_ERROR(rmt_enable(dev->chan), err, TAG, "enable RMT channel failed");

    if (dev->en_gpio >= 0) {
        gpio_set_level(dev->en_gpio, !DRV8825_EN_ACTIVE_LEVEL); /* start disabled */
    }

    ESP_LOGI(TAG, "init done: STEP=%d DIR=%d speed=%" PRIu32 " Hz ramp=%" PRIu32 " steps",
             cfg->step_gpio, cfg->dir_gpio, dev->speed_hz, dev->accel_steps);
    return ESP_OK;

err:
    if (dev->accel_enc) {
        rmt_del_encoder(dev->accel_enc);
        dev->accel_enc = NULL;
    }
    if (dev->decel_enc) {
        rmt_del_encoder(dev->decel_enc);
        dev->decel_enc = NULL;
    }
    if (dev->cruise_enc) {
        rmt_del_encoder(dev->cruise_enc);
        dev->cruise_enc = NULL;
    }
    if (dev->chan) {
        rmt_del_channel(dev->chan);
        dev->chan = NULL;
    }
    return ret;
}

esp_err_t drv8825_deinit(drv8825_t *dev)
{
    ESP_RETURN_ON_FALSE(dev, ESP_ERR_INVALID_ARG, TAG, "invalid argument");
    esp_err_t ret = ESP_OK;

    if (dev->chan) {
        rmt_disable(dev->chan); /* error on a never-enabled channel: ignore */
        ret = rmt_del_channel(dev->chan);
        dev->chan = NULL;
    }
    if (dev->accel_enc) {
        rmt_del_encoder(dev->accel_enc);
        dev->accel_enc = NULL;
    }
    if (dev->decel_enc) {
        rmt_del_encoder(dev->decel_enc);
        dev->decel_enc = NULL;
    }
    if (dev->cruise_enc) {
        rmt_del_encoder(dev->cruise_enc);
        dev->cruise_enc = NULL;
    }
    return ret;
}

esp_err_t drv8825_enable(drv8825_t *dev, bool enable)
{
    ESP_RETURN_ON_FALSE(dev, ESP_ERR_INVALID_ARG, TAG, "invalid argument");
    if (dev->en_gpio < 0) {
        return ESP_OK; /* nENBL is hard-wired to GND */
    }
    gpio_set_level(dev->en_gpio, enable ? DRV8825_EN_ACTIVE_LEVEL : !DRV8825_EN_ACTIVE_LEVEL);
    return ESP_OK;
}

esp_err_t drv8825_set_microstep(drv8825_t *dev, drv8825_microstep_t microstep)
{
    ESP_RETURN_ON_FALSE(dev, ESP_ERR_INVALID_ARG, TAG, "invalid argument");
    ESP_RETURN_ON_FALSE(dev->m0_gpio >= 0, ESP_ERR_NOT_SUPPORTED, TAG,
                        "M0/M1/M2 are not wired to GPIOs, microstep is fixed by hardware");
    apply_microstep(dev, microstep);
    return ESP_OK;
}

esp_err_t drv8825_move(drv8825_t *dev, int32_t steps)
{
    ESP_RETURN_ON_FALSE(dev && dev->chan, ESP_ERR_INVALID_STATE, TAG, "driver not initialized");
    if (steps == 0) {
        return ESP_OK;
    }

    ESP_RETURN_ON_ERROR(drv8825_enable(dev, true), TAG, "enable failed");

    gpio_set_level(dev->dir_gpio, steps > 0 ? dev->dir_cw_level : !dev->dir_cw_level);
    esp_rom_delay_us(2); /* DRV8825 t_su(DIR before STEP) is 650 ns */

    uint32_t total = steps > 0 ? (uint32_t)steps : (uint32_t)(-(int64_t)steps);
    uint32_t ramp = dev->accel_steps;
    if (total < 2 * ramp) {
        /* shortcut: no triangular profile, short moves run at constant speed */
        ramp = 0;
    }
    uint32_t cruise = total - 2 * ramp;
    assert(2 * ramp + cruise == total); /* every requested step is transmitted exactly once */
    rmt_transmit_config_t tx_config = {.loop_count = 0};

    if (ramp) {
        ESP_RETURN_ON_ERROR(rmt_transmit(dev->chan, dev->accel_enc, &ramp, sizeof(ramp), &tx_config), TAG,
                            "accel transmit failed");
    }
    if (cruise) {
        ESP_RETURN_ON_ERROR(rmt_transmit(dev->chan, dev->cruise_enc, &cruise, sizeof(cruise), &tx_config), TAG,
                            "cruise transmit failed");
    }
    if (ramp) {
        ESP_RETURN_ON_ERROR(rmt_transmit(dev->chan, dev->decel_enc, &ramp, sizeof(ramp), &tx_config), TAG,
                            "decel transmit failed");
    }

    return rmt_tx_wait_all_done(dev->chan, -1);
}
